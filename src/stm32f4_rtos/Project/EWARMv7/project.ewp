# IAR project project.ewp, settings and files
configuration Flash (ARM)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp\inc; ..\..\User\bsp; ..\..\User; ..\..\FreeRTOS\include; ..\..\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\User\usbh_mass_storage; ..\..\User\fatfs\src; ..\..\User\fatfs\src\option; ..\..\User\malloc; ..\..\User\modbus; ..\..\User\esp8266; ..\..\User\JSON; ..\..\User\MQTTPacket\src; ..\..\User\MQTTPacket\samples; ..\..\User\MQTTPacket; ..\..\User\SMEC98SP\Header
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\User
  OBJCOPY.OOCOutputFile: MainBoard191026.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/: bkp_pwr.c
    ../../User/bsp/: bsp.c bsp.h bsp_adc.c bsp_closeSW.c bsp_dac.c bsp_relay.c bsp_sdwe050c17.c bsp_servomotor.c bsp_spi.c bsp_stepmotor.c bsp_sw_onoff.c bsp_w25qxx.c bsp_watchdog.c encoder_tim.c stm32f4xx_assert.c stm32f4xx_it.c
    ../../User/bsp/src/: bsp_dwt.c bsp_key.c bsp_led.c bsp_sdio_sd.c bsp_tim_pwm.c bsp_timer.c bsp_uart_fifo.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
  group FatFS
    ../../User/fatfs/src/option/: cc936.c
    ../../User/fatfs/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Malloc
    ../../User/malloc/: malloc.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group Modbus
    ../../User/modbus/: mcheck.c modbus.c
  group SEMC98SE
    ../../User/SMEC98SP/Source/: des.c iic_smec98sp.c sha1.c smec98sp.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USB_Host_Library
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_OTG_Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USBH MassStorage
    ../../User/usbh_mass_storage/: usb_bsp.c usb_conf.h usbh_bsp_msc.h usbh_conf.h usbh_it.c usbh_usr.c usbh_usr.h
  group User
    ../../User/: apptask.c demo_fatfs.c FreeRTOSConfig.h includes.h main.c para.c product_cal.c protocol.c rc522.c SysInfoTest.c
    ../../User/bsp/: page_weimi.c
  group WIFI/ESP8266
    ../../User/esp8266/: esp8266_handler.c esp8266_init.c
  group WIFI/JSON
    ../../User/JSON/: cJSON.c
  group WIFI/MQTT
    ../../User/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group WIFI/MQTT/DEMO
    ../../User/MQTTPacket/: mqtt.h timer_platform.c
    ../../User/MQTTPacket/samples/: pub0sub1.c transport.c
