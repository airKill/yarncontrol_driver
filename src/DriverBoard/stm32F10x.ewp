# IAR project stm32F10x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: $PROJ_DIR$; CMSIS; FWlib\inc; USER; USER\driver\inc; USER\middle\inc; USER\APP\inc; $TOOLKIT_DIR$\inc; USER\modbus; USER\malloc; FreeRTOS\include; FreeRTOS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SlaveBoard181224_0.8减速0.3停止.bin
  ILINK.IlinkOutputFile: stm32F10x.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/: core_cm3.c system_stm32f10x.c
    CMSIS/startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group FreeRTOS/Ports
    FreeRTOS/: heap_4.c port.c portasm.s portmacro.h
  group FreeRTOS/Source
    FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FWlib
    FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MALLOC
    USER/malloc/: malloc.c
  group MODBUS
    USER/modbus/: mcheck.c modbus.c
  group USER
    USER/: adc.c apptask.c bsp_config.c bsp_dwt.c bsp_key.c bsp_timer.c delay.c filter.c hc08.c hx711.c main.c main.h memory.c motor.c para.c protocol.c stm32f10x_it.c switch.c
    FreeRTOS/: FreeRTOSConfig.h
