# Keil uVision project SMEC98SPfor8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: SMEC98SPfor8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SMEC98SP\Header
  group Source Group 1
    ./: main.c
  group SMEC98SP
    ./SMEC98SP/Source/: Des.c iic_smec98sp.c SHA1.C SMEC98SP.c
