# Keil uVision project SMEC98SPforSTM32.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SMEC98SPforSTM32 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\User;..\STM32_FWLib\inc;..\STM32_FWLib\src;.\SMEC98SP\Header
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../CMSIS/STARTUP/: startup_stm32f10x_md.s
  group User
    ./: stm32f10x_it.c main.c stm32f10x_conf.h stm32f10x_it.h config.h Types.h util.h util.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h system_stm32f10x.h core_cm3.h
  group STM32_FWLib
    ../STM32_FWLib/src/: misc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_adc.c
    ../STM32_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group SMEC98SP
    ./SMEC98SP/Source/: des.c iic_smec98sp.c sha1.c smec98sp.c
software components: CMSIS:CORE 4.3.0
