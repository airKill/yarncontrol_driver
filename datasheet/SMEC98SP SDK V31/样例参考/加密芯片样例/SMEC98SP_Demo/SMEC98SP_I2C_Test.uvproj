# Keil uVision project SMEC98SP_I2C_Test.uvproj, settings and files
target SMEC98SP (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: SMEC98SP_I2C_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SrcApi\;.\SrcTest\
  group Source Group 1
    ./SrcApi/: SHA1.C SMEC98SP_I2C_hard_api.c i2c_test.a51 SMEC98SP_I2C_STARTUP.a51 SMEC98SP_V30.LIB
    ./SrcTest/: c_root.C
